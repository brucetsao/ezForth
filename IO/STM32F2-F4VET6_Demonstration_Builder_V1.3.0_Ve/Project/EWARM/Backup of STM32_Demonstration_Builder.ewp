# IAR project Backup of STM32_Demonstration_Builder.ewp, settings and files
configuration STM322xG-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL; USE_3D_OBJECTS
  ICCARM.CCIncludePath2: ..\Config; ..\Core\Devices\STM32F2xx; ..\Core\Graphics; ..\Core\Mod_Manager; ..\Core\User; ..\Core\Lib; ..\Modules; ..\Modules\Audio_Player; ..\Modules\Audio_Recorder; ..\Modules\Calendar; ..\Modules\Camera; ..\Modules\Console; ..\Modules\Credits; ..\Modules\Ethernet; ..\Modules\File_Manager; ..\Modules\serial; ..\Modules\Common; ..\Modules\Image_Browser; ..\Modules\System; ..\Modules\USBD; ..\..\Libraries\Embedded_GUI_Library\inc; ..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\HID\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\Audio\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\Libraries\Audio_Codecs\MP3_Codec\inc; ..\..\Libraries\Audio_Codecs\MP3_Codec\lib; ..\..\Libraries\Audio_Codecs\WMA_Codec\inc; ..\..\Libraries\Audio_Codecs\WMA_Codec\lib; ..\..\Libraries\Audio_Codecs\WMA_Codec\asf; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\Common; ..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\Utilities\Third_Party\fat_fs\inc; ..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\Utilities\Third_Party\FreeRTOS\Source\include; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32\FreeRTOS; ..\..\Utilities\Third_Party\jpeg-8d\include; ..\..\Utilities\STM32_Audio\Addons\SpiritDSP_Equalizer; ..\..\Utilities\STM32_Audio\Addons\SpiritDSP_LoudnessControl; ..\..\Utilities\STM32_Audio\Common; ..\..\Utilities\STM32_Audio\STM322xG_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM322xG_EVAL_Demonstration_Builder.hex
  ILINK.IlinkOutputFile: STM322xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324xG-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL; USE_3D_OBJECTS
  ICCARM.CCIncludePath2: ..\Config; ..\Core\Devices\STM32F4xx; ..\Core\Graphics; ..\Core\Mod_Manager; ..\Core\User; ..\Core\Lib; ..\Modules; ..\Modules\Audio_Player; ..\Modules\Audio_Recorder; ..\Modules\Calendar; ..\Modules\Camera; ..\Modules\Console; ..\Modules\Credits; ..\Modules\Ethernet; ..\Modules\File_Manager; ..\Modules\serial; ..\Modules\Common; ..\Modules\Image_Browser; ..\Modules\System; ..\Modules\USBD; ..\..\Libraries\Embedded_GUI_Library\inc; ..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\HID\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\Audio\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\STM32F4x7_ETH_Driver\inc; ..\..\Libraries\Audio_Codecs\MP3_Codec\inc; ..\..\Libraries\Audio_Codecs\MP3_Codec\lib; ..\..\Libraries\Audio_Codecs\WMA_Codec\inc; ..\..\Libraries\Audio_Codecs\WMA_Codec\lib; ..\..\Libraries\Audio_Codecs\WMA_Codec\asf; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\Common; ..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL; ..\..\Utilities\Third_Party\fat_fs\inc; ..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Utilities\Third_Party\FreeRTOS\Source\include; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32\FreeRTOS; ..\..\Utilities\Third_Party\jpeg-8d\include; ..\..\Utilities\STM32_Audio\Addons\SpiritDSP_Equalizer; ..\..\Utilities\STM32_Audio\Addons\SpiritDSP_LoudnessControl; ..\..\Utilities\STM32_Audio\Common; ..\..\Utilities\STM32_Audio\STM3240_41_G_EVAL
  OBJCOPY.OOCOutputFile: STM324xG_EVAL_Demonstration_Builder.hex
  ILINK.IlinkOutputFile: STM324xG-EVAL.out
  ILINK.IlinkIcfFile: stm32f40xx_flash.icf
configuration STM324x7I-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F437II ST STM32F437II
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427X; USE_STM324x7I_EVAL; USE_3D_OBJECTS
  ICCARM.CCIncludePath2: ..\Config; ..\Core\Devices\STM32F4xx; ..\Core\Graphics; ..\Core\Mod_Manager; ..\Core\User; ..\Core\Lib; ..\Modules; ..\Modules\Audio_Player; ..\Modules\Audio_Recorder; ..\Modules\Calendar; ..\Modules\Camera; ..\Modules\Console; ..\Modules\Credits; ..\Modules\Ethernet; ..\Modules\File_Manager; ..\Modules\serial; ..\Modules\Common; ..\Modules\Image_Browser; ..\Modules\System; ..\Modules\USBD; ..\..\Libraries\Embedded_GUI_Library\inc; ..\..\Libraries\Embedded_GUI_HAL\inc; ..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\HID\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\Audio\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\STM32F4x7_ETH_Driver\inc; ..\..\Libraries\Audio_Codecs\MP3_Codec\inc; ..\..\Libraries\Audio_Codecs\MP3_Codec\lib; ..\..\Libraries\Audio_Codecs\WMA_Codec\inc; ..\..\Libraries\Audio_Codecs\WMA_Codec\lib; ..\..\Libraries\Audio_Codecs\WMA_Codec\asf; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\Common; ..\..\Utilities\STM32_EVAL\STM324x7I_EVAL; ..\..\Utilities\Third_Party\fat_fs\inc; ..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Utilities\Third_Party\FreeRTOS\Source\include; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32; ..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32\FreeRTOS; ..\..\Utilities\Third_Party\jpeg-8d\include; ..\..\Utilities\STM32_Audio\Addons\SpiritDSP_Equalizer; ..\..\Utilities\STM32_Audio\Addons\SpiritDSP_LoudnessControl; ..\..\Utilities\STM32_Audio\Common; ..\..\Utilities\STM32_Audio\STM324x7I_EVAL
  OBJCOPY.OOCOutputFile: STM324x7I_EVAL_Demonstration_Builder.hex
  ILINK.IlinkOutputFile: STM324x7I-EVAL.out
  ILINK.IlinkIcfFile: stm32f427x_flash.icf
  group Appli/Core/Devices/STM32F2xx
    ./: startup_stm32f2xx.s
    ../Core/Devices/STM32F2xx/: system_stm32f2xx.c
  group Appli/Core/Devices/STM32F2xx/STM322xG-EVAL
    ../../Utilities/STM32_EVAL/stm322xg_eval/: stm322xg_eval.c
    ../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_fsmc_sram.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c stm322xg_eval_sdio_sd.c
  group Appli/Core/Devices/STM32F2xx/STM32F2x7_ETH_Driver
    ../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group Appli/Core/Devices/STM32F2xx/STM32F2xx_StdPeriph_Driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_adc.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_misc.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group Appli/Core/Devices/STM32F4xx
    ./: startup_stm32f40xx.s startup_stm32f427x.s
    ../Core/Devices/STM32F4xx/: system_stm32f4xx.c
  group Appli/Core/Devices/STM32F4xx/STM324x7I-EVAL
    ../../Utilities/STM32_EVAL/STM324x7I_EVAL/: stm324x7i_eval.c stm324x7i_eval_fsmc_sram.c stm324x7i_eval_ioe.c stm324x7i_eval_lcd.c stm324x7i_eval_sdio_sd.c
  group Appli/Core/Devices/STM32F4xx/STM324xG-EVAL
    ../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_fsmc_sram.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c stm324xg_eval_sdio_sd.c
  group Appli/Core/Devices/STM32F4xx/STM32F4x7_ETH_Driver
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Appli/Core/Devices/STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_misc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Appli/Core/Graphics
    ../Core/Graphics/: gl_ext.c gl_mgr.c messages.c
  group Appli/Core/Lib
    ../Core/Lib/: file_utils.c libjpeg_utils.c mem_utils.c str_utils.c time_utils.c
  group Appli/Core/Manager
    ../Core/Mod_manager/: mod_core.c
  group Appli/Core/User
    ../Core/User/: bsp.c eth_bsp.c fatfs_drv.c main.c stm32xxx_it.c usb_bsp.c usbh_usr.c
  group Appli/Modules/Audio_Player
    ../Modules/Audio_Player/: app_audio.c mod_audio.c
  group Appli/Modules/Audio_Recorder
    ../Modules/Audio_Recorder/: app_recorder.c mod_recorder.c
  group Appli/Modules/Calendar
    ../Modules/Calendar/: app_rtc.c mod_calendar.c
  group Appli/Modules/Camera
    ../Modules/Camera/: app_camera.c camera_api.c mod_camera.c
  group Appli/Modules/Common
    ../Modules/Common/: dcmi_ov2640.c dcmi_ov9655.c
  group Appli/Modules/Credits
    ../Modules/Credits/: mod_credits.c
  group Appli/Modules/Ethernet
    ../Modules/Ethernet/: app_ethernet.c fs.c ipcam_api.c mod_ethernet.c
  group Appli/Modules/Image
    ../Modules/Image_Browser/: app_image.c image_bmp.c image_jpeg.c mod_image.c
  group Appli/Modules/Serial
    ../Modules/Serial/: mod_serial.c
  group Appli/Modules/System
    ../Modules/System/: mod_system.c
  group Appli/Modules/USB device
    ../Modules/USBD/: app_usbd.c mod_usbd.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group Appli/Modules/Utilities
    ../Modules/Console/: app_console.c mod_console.c
    ../Modules/File_Manager/: mod_filemgr.c
  group Libraries/STM32_GL/GUI_Core
    ../../Libraries/Embedded_GUI_Library/src/: cursor.c gl_fonts.c graphicObject.c images.c
  group Libraries/STM32_GL/GUI_HAL
    ../../Libraries/Embedded_GUI_HAL/src/: JoyHal.c LcdHal.c TscHal.c
  group Libraries/STM32_USB/Device/Class/HID
    ../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group Libraries/STM32_USB/Device/Class/MSC
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Libraries/STM32_USB/Device/Core
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group Libraries/STM32_USB/Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group Libraries/STM32_USB/Host/Class/MSC
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group Libraries/STM32_USB/Host/Core
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group Utilities/Audio/Addons
    ../../Utilities/STM32_Audio/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m3.a lib_equalizer_cortex_m4.a
    ../../Utilities/STM32_Audio/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m3.a lib_loudness_cortex_m4.a
  group Utilities/Audio/Common
    ../../Utilities/STM32_Audio/Common/: songutilities.c stm32_audio_decoders.c stm32_audio_in_if.c stm32_audio_out_if.c wavprocess.c
  group Utilities/Audio/STM322xG_EVAL
    ../../Utilities/STM32_Audio/STM322xG_EVAL/: stm322xg_audio_codec.c stm322xg_audio_recorder.c
  group Utilities/Audio/STM3240_41_G_EVAL
    ../../Utilities/STM32_Audio/STM3240_41_G_EVAL/: stm324xg_audio_codec.c stm324xg_audio_recorder.c
  group Utilities/Audio/STM324x7I_EVAL
    ../../Utilities/STM32_Audio/STM324x7I_EVAL/: stm324x7i_audio_codec.c stm324x7i_audio_recorder.c
  group Utilities/FAT_FS
    ../../Utilities/Third_Party/fat_fs/src/option/: ccsbcs.c syscall.c
    ../../Utilities/Third_Party/fat_fs/src/: ff.c
  group Utilities/FreeRTOS/Core
    ../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Utilities/FreeRTOS/Memory
    ../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Utilities/FreeRTOS/Portable/STM32F2xx
    ../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port_cm3.c portasm_cm3.s
  group Utilities/FreeRTOS/Portable/STM32F4xx
    ../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port_cm4.c portasm_cm4.s
  group Utilities/LibJPEG
    ../../Utilities/Third_Party/jpeg-8d/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group Utilities/LwIP/API
    ../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Utilities/LwIP/Core
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Utilities/LwIP/Core/IPV4
    ../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Utilities/LwIP/Netif
    ../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
  group Utilities/LwIP/Netif/STM32
    ../../Utilities/Third_Party/lwip_v1.3.2/port/STM32/FreeRTOS/: ethernetif.c sys_arch.c
